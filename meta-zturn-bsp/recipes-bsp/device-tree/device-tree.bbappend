FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI = " \
    file://zynq-zturn.dts \
    file://zynq-7000.dtsi \
    file://skeleton.dtsi \
"

